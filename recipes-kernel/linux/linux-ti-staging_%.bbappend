FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI_append_j7-evm = " file://0001-techdev-dts.patch"
